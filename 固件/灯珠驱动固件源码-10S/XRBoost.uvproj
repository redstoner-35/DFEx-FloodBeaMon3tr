# Keil uVision project XRBoost.uvproj, settings and files
target XTRBoost-GaN-10S (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: XTRBoost-GaN-10S +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: EnableStdGPIO,USING_LED_FV8011I,FullPowerStrobe,FullPowerBeacon
  c include: .\StdDriver\inc;.\Hardware;.\include\Hardware;.\include\Logic;.\include\Middleware;.\include\System
  link misc: REMOVEUNUSED
  group User
    ./: STARTUP_CMS8S6990.A51 main.c
  group Stdlib
    ./StdDriver/src/: gpio.c SysReset.c
  group Hardware
    ./Hardware/: delay.c ADCCfg.c LEDMgmt.c NTC.c SideKey.c PWM.c Flash.c
  group MiddleWare
    ./MiddleWare/: OutputChannel.c SysConfig.c BattVoltDisplay.c LocateLED.c
  group Logic
    ./Logic/: ModeControl.c TempControl.c Sleep.c SelfTest.c SOS.c LowVoltageProt.c SpecialMode.c Beacon.c Strobe.c SetupMenu.c
  group Config
    ./Hardware/: PinDefs.h
    ./include/Middleware/: DefaultConfiguration.h
