# Keil uVision project XRFan-Ultra.uvproj, settings and files
target XRFan-Ultra (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: XRFan-Ultra +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: EnableStdGPIO,EnableHyper1S
  c include: .\include\System;.\StdDriver\inc;.\Hardware;.\include\Hardware;.\include\Middleware;.\include\Logic
  group User
    ./: STARTUP_CMS8S6990.A51 main.c
  group Stdlib
    ./StdDriver/src/: gpio.c SysReset.c
  group Hardware
    ./Hardware/: PinDefs.h delay.c SideKey.c LEDMgmt.c ADCCfg.c PWM.c LVDCtrl.c UnusedIO.c Flash.c NTC.c
  group Logic
    ./Logic/: BattVoltDisplay.c OutputChannel.c ModeSel.c LowVoltageProt.c Sleep.c SysConfig.c TempControl.c
