# Keil uVision project Battery.uvproj, settings and files
target Battery (MCS-51)
  device: CMS8S6990 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) CLOCK(24000000) MODDP2
  output: Battery +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\include\Hardware;.\include\System;.\Hardware;.\StdDriver\inc;.\include\MiddleWare
  group User
    ./: STARTUP_CMS8S6990.A51 main.c
  group Stdlib
    ./StdDriver/src/: gpio.c i2c.c SysReset.c
  group Hardware
    ./Hardware/: PinDefs.h delay.c LEDMgmt.c SideKey.c SH367303.c NTC.c BALDRV.c WDT.c
  group Middleware
    ./Middleware/: SH36_REG.c ChargeMgmt.c
